SRC_URI += "file://0001-Change-panic-strategy.patch"
SRC_URI += "file://0001-Add-aziot-keys.h-unused-in-current-recipe-version.patch"
SRC_URI += "file://0001-tpm_c-shared.patch"
SRC_URI += "file://0001-tpm_utpm.patch"
